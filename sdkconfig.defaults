## sdkconfig.defaults
```kconfig
# Completely disable brownout detector for USB cable operation
CONFIG_ESP32_BROWNOUT_DET=n
CONFIG_BROWNOUT_DET=n
```
